# Keil uVision project Course_Design.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Course_Design +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\project_0920
  group Source Group 1
    ./: STARTUP.A51 main.c LCD1602.c DS1302.c Delay.c DS18B20.c HC_SR04.c Int0.c IR.c OneWire.c Timer0.c
